# IAR project spectrum_analyzer.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; JOYSTICK_ISR
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/common/cc8051; ../../../source/Components/targets/srf05_soc; ../../../source/Components/radios/cc2530
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: D:\IAR Systems\Embedded Workbench 6.0 Evaluation\8051\config\devices\Texas Instruments\lnk51ew_cc2530F256.xcl
  group application
    ../../../source/apps/spectrum_analyzer/: spectrum_analyzer.c
  group hal/common
    ../../../source/Components/common/cc8051/: hal_cc8051.h
    ../../../source/Components/common/: hal_defs.h hal_int.c hal_types.h
    ../../../source/Components/targets/common/: hal_lcd_srf05.c
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h
  group hal/rf
    ../../../source/Components/targets/interface/: hal_rf.h hal_rf_util.h
  group hal/rf/cc2530
    ../../../source/Components/radios/cc2530/: adc.c adc.h clock.c clock.h hal_mcu.c hal_rf.c hal_rf_util.c
  group hal/srf05_soc
    ../../../source/Components/targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_digio.c hal_joystick.c hal_led.c
  group utilities
    ../../../source/Components/utils/: util.c util.h util_lcd.c util_lcd.h util_menu.h
