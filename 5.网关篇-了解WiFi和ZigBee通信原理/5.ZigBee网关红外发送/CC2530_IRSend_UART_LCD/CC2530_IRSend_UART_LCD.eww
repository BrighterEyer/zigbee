<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC2530_IRSend_UART_LCD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


